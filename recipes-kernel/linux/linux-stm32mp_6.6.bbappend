FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Device-tree-modifications-for-the-logic-analyzer-dem.patch"

