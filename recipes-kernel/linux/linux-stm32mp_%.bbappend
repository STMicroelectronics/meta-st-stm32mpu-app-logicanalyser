# Configure recipe for CubeMX
inherit cubemx-stm32mp
CUBEMX_DTB_SRC_PATH ?= "arch/arm/boot/dts"

